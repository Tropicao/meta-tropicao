require base_image_iot.inc

IMAGE_INSTALL_append = "\
"
