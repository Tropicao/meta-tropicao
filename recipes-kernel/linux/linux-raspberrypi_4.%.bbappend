FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_raspberrypi3 += "file://0001-add-mrf24j40-support.patch"

